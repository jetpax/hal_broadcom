## zephyr/Kconfig
```kconfig
# Copyright (c) 2026 Jonathan Elliot Peace <jep@alphabetiq.com>
# SPDX-License-Identifier: Apache-2.0

config ZEPHYR_HAL_BROADCOM_MODULE
	bool
```
